# IAR project F_Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Application_SWC_1.c Application_SWC_2.c CDD.c Common_Macros.h Compiler.h Dio.c Dio.h Dio_Cfg.h Dio_LCfg.c Dio_LCfg.h Dio_Regs.h Dio_Types.h main.c Platform_Types.h Port_Cfg.h Port_LCfg.c Port_LCfg.h Port_Regs.h Port_Types.h PortF.c PortF.h Rte.c Rte.h Rte_Application_SWC_1.h Rte_Application_SWC_2.h Rte_CDD.h Rte_Type.h startup_ewarm.c Std_Types.h Systick_Driver.c Systick_Driver.h tm4c123gh6pm_registers.h
